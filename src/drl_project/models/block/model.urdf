Commit message: debugging reset error

File: src/drl_project/models/block/model.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: geometry visual box size=0.05 0.05 0.05
